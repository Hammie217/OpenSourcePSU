# Repository Hammie217/OpenSourcePSU

## KiCad design Kicad/OpenPSU.kicad_pcb

Parts:
C1, C2, C15: 0.1u; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C3, C14: 1u; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C4, C5: 22p; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C6, C7, C13: 4700uF; CP_Radial_D16.0mm_P7.50mm
C8: 2.2u; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C9, C11: 470uF; CP_Radial_D8.0mm_P3.50mm
C10, C12, C16, C17: 100n; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C(Tantalum)1: 10u; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C?(Ceramic)1: 0.1u; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1, D2: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D3, D4, D5, D6, D7, D8, D10: D; D_SOD-123F
D9: D_Zener; D_MiniMELF_Handsoldering
H1: Live; MountingHole_2.5mm_Pad
H2: Neutral; MountingHole_2.5mm_Pad
H3: Out+; MountingHole_4mm_Pad
H4: Out-; MountingHole_4mm_Pad
J1: Conn_01x10_Female; PinHeader_1x10_P2.54mm_Vertical
J2: Barrel_Jack; BarrelJack_Horizontal
J3: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
K1: G5V-1; Relay_SPDT_Omron_G5V-1
Q1, Q2, Q5: MMBT3904; SOT-23_Handsoldering
Q3, Q4: TIP3055G; TO-247-3_Vertical
R1, R2, R3, R5, R6, R32: 330; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R4, R22, R27: 10k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R7, R8, R9, R10, R11, R12, R13, R14, R15, R16: 1; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R17: 680; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R18: 3k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R19: 100; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R20, R30: 27k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R21, R23: 220R; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R24: 100R; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R25, R29: 10kR; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R26, R28: 180k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R31: 68k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R33: 100k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R34, R35: 4.7k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
SW1, SW2: Rotary_Encoder; RotaryEncoder_Alps_EC12E_Vertical_H20mm
SW3: SW_Mains; TerminalBlock_bornier-2_P5.08mm
T1: Transformer_1P_1S; Transformer_Toroid_Horizontal_D18.0mm
U1: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm
U2, U3: LM358; SOIC-8_3.9x4.9mm_P1.27mm
U4: LT3080xST; SOT-223
U5: LM334Z; TO-92_Inline
U6: L78L33_SOT89; SOT-89-3_Handsoldering
U7: LM336; TO-92_Inline
U8: REF3020; SOT-23_Handsoldering
U9: MAX4080T; SOIC-8_3.9x4.9mm_P1.27mm
U10: MC78M05_TO252; TO-252-2
U11: INA219AxD; SOIC-8_3.9x4.9mm_P1.27mm
U12: MCP4922; SOIC-14_3.9x8.7mm_P1.27mm
Y1: 20MHz Crystal; Crystal_HC52-8mm_Vertical

Connections:
2.048V: U1.20 (AREF), U8.2 (OUT), U12.11 (VrefB), U12.13 (VrefA)
3.3V: C1.1, C12.1, C15.1, C(Tantalum)1.1, C?(Ceramic)1.1, J1.1, J3.2, R4.1, R22.1, R34.1, R35.1, U1.4 (VCC), U1.6 (VCC), U1.18 (AVCC), U6.1 (OUT), U8.1 (IN), U11.5 (VS), U12.1 (Vdd), U12.9 (~SHDN)
5V: C10.1, C17.1, K1.2, R1.2, R2.2, R3.2, U6.3 (IN), U10.3 (VO)
CurrentLimit: Q1.1 (B), Q2.1 (B), U2.7
Encoder1A: SW1.A, U1.26 (PC3)
Encoder1B: SW1.B, U1.25 (PC2)
Encoder2A: SW2.A, U1.2 (PD4)
Encoder2B: SW2.B, U1.1 (PD3)
GND: C1.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C(Tantalum)1.2, C?(Ceramic)1.2, D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), H4.1, J1.2, J2.2, J3.6, K1.1, K1.9, Q1.2 (E), Q2.2 (E), R5.1, R6.1, R18.1, R24.2, R25.2, R27.2, R30.2, SW1.C, SW2.C, U1.3 (GND), U1.5 (GND), U1.21 (GND), U2.4 (V-), U3.4 (V-), U5.3, U6.2 (GND), U7.3 (A), U8.3 (GND), U9.4 (GND), U10.2 (GND), U11.1 (A1), U11.2 (A0), U11.6 (GND), U12.8 (~LDAC), U12.12 (Vss)
Io: C14.1, R32.2, U2.5 (+)
IoRef: U2.6 (-), U12.10 (VB)
MISO: J3.1, U1.16 (PB4)
MOSI: J1.7, J3.4, U1.15 (PB3), U12.5 (SDI)
unnamed: C8.1, D3.2 (A), D9.1 (K), H3.1, R26.1, R28.1, U4.2 (OUT), U4.4 (OUT), U5.1
unnamed: C9.1, R21.1, R23.2
unnamed: C11.1, Q3.1 (B), R23.1, R25.1
unnamed: C13.1, D10.2 (A), K1.10, Q4.3 (E), Q5.3 (C), U3.5 (+)
unnamed: C16.1, Q5.2 (E), U10.1 (VI)
unnamed: D1.1 (K), R5.2
unnamed: D1.2 (A), U1.23 (PC0)
unnamed: D2.1 (K), R6.2
unnamed: D2.2 (A), U1.24 (PC1)
unnamed: D4.2 (A), D6.1 (K), T1.4 (SB)
unnamed: D5.2 (A), D7.1 (K), T1.3 (SA)
unnamed: H1.1, SW3.1 (A)
unnamed: H2.1, T1.2 (AB)
unnamed: J1.8, R1.1
unnamed: J1.9, R2.1
unnamed: J1.10, R3.1
unnamed: Q1.3 (C), R4.2, U1.31 (PD1)
unnamed: Q2.3 (C), R17.1, R19.2
unnamed: Q3.3 (E), Q4.1 (B)
unnamed: Q5.1 (B), U3.7
unnamed: R17.2, U2.1
unnamed: R18.2, R20.2, U2.2 (-)
unnamed: R24.1, U5.2
unnamed: R29.2, U3.3 (+), U7.2 (K)
unnamed: R30.1, R31.2, U3.2 (-)
unnamed: R31.1, R33.2
unnamed: R32.1, U9.5 (OUT)
unnamed: R33.1, U3.1, U3.6 (-)
unnamed: SW3.2 (B), T1.1 (AA)
RESET: J1.3, J3.5, R22.2, U1.29 (~RESET~/PC6)
RS: J1.4, U1.12 (PB0)
SCK: J1.6, J3.3, U1.17 (PB5), U12.4 (SCK)
SCL0: R35.2, U1.28 (PC5), U11.4 (SCL)
SDA0: R34.2, U1.27 (PC4), U11.3 (SDA)
SS0: J1.5, U1.32 (PD2)
SS1: U1.13 (PB1), U12.3 (~CS)
Sense+: C2.2, K1.5, K1.6, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, U2.8 (V+), U9.1 (RS+), U9.2 (Vcc), U11.8 (IN+)
Sense-: C2.1, C3.1, D3.1 (K), R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, U4.3 (IN), U9.8 (RS-), U11.7 (IN-)
VSet: R19.1, R20.1, U4.1 (SET)
VoRef: U2.3 (+), U12.14 (VA)
Voutput: R26.2, R27.1, R28.2, U1.11 (PD7)
XTAL1: C4.1, U1.7 (XTAL1/PB6), Y1.1
XTAL2: C5.1, U1.8 (XTAL2/PB7), Y1.2
unreg: C6.1, C7.1, D4.1 (K), D5.1 (K), D8.1 (K), D10.1 (K), J2.1, Q3.2 (C), Q4.2 (C), R21.2, R29.1, U3.8 (V+)

Notes on the sheet:
10x Gain for 0-20.48V
Mains to 18.22V out. Turn on at 18V. 1mV ripple.
DAC
Current ADC
Gain=20. 0-2V Out for 0-1A
Voltage Reference
Current Sense
Voltage output signal
Linear Output stage
3.3V regulator
AVR ISP Header
Clock Signal
ADDR=0
SPI1
SPI0
Rotary Encoders
SPI1 CS0
CS1
I2C0
LCD Display
Microprocessor
Linear power supply
07/06/2020

Board: 2 copper layers, 100.0 x 100.0 mm, 96 parts (1 on the bottom side), 57 nets.

Other parts of the board:
LOGO: LOGO16x16
LOGO#2: LOGO16x16

File Kicad/OpenPSUBOMV2.csv:

"Id";"Designator";"Package";"Quantity";"Designation";"Supplier and ref";
1;"REF**";"KiCad-Logo_8mm_SilkScreen";1;"KiCad-Logo_8mm_SilkScreen";;;
2;"REF**";"OSHW-Logo2_9.8x8mm_SilkScreen";1;"OSHW-Logo2_9.8x8mm_SilkScreen";;;
3;"LOGO,LOGO";"LOGO16x16";2;"";;;
4;"J3";"PinHeader_2x03_P2.54mm_Vertical";1;"Conn_02x03";;;
5;"U4";"SOT-223";1;"LT3080xST";;;
6;"R34,R35";"R_0603_1608Metric_Pad1.05x0.95mm_HandSolder";2;"4.7k";;;
7;"C1,C2,C15,C?(Ceramic)1";"C_0603_1608Metric_Pad1.05x0.95mm_HandSolder";4;"0.1u";;;
8;"C3,C14";"C_0603_1608Metric_Pad1.05x0.95mm_HandSolder";2;"1u";;;
9;"C4,C5";"C_0603_1608Metric_Pad1.05x0.95mm_HandSolder";2;"22p";;;
10;"C6,C7,C13";"CP_Radial_D16.0mm_P7.50mm";3;"4700uF";;;
11;"C8";"C_0603_1608Metric_Pad1.05x0.95mm_HandSolder";1;"2.2u";;;
12;"C9,C11";"CP_Radial_D8.0mm_P3.50mm";2;"470uF";;;
13;"C10,C12,C16,C17";"C_0603_1608Metric_Pad1.05x0.95mm_HandSolder";4;"100n";;;
14;"C(Tantalum)1";"C_1206_3216Metric_Pad1.42x1.75mm_HandSolder";1;"10u";;;
15;"D1,D2";"LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder";2;"LED";;;
16;"D3,D4,D5,D6,D7,D8,D10";"D_SOD-123F";7;"D";;;
17;"D9";"D_MiniMELF_Handsoldering";1;"D_Zener";;;
18;"H1";"MountingHole_2.5mm_Pad";1;"Live";;;
19;"H2";"MountingHole_2.5mm_Pad";1;"Neutral";;;
20;"H3";"MountingHole_4mm_Pad";1;"Out+";;;
21;"H4";"MountingHole_4mm_Pad";1;"Out-";;;
22;"J1";"PinHeader_1x10_P2.54mm_Vertical";1;"Conn_01x10_Female";;;
23;"J2";"BarrelJack_Horizontal";1;"Barrel_Jack";;;
24;"K1";"Relay_SPDT_Omron_G5V-1";1;"G5V-1";;;
25;"Q1,Q2,Q5";"SOT-23_Handsoldering";3;"MMBT3904";;;
26;"Q3,Q4";"TO-247-3_Vertical";2;"TIP3055G";;;
27;"R1,R2,R3,R5,R6,R32";"R_0603_1608Metric_Pad1.05x0.95mm_HandSolder";6;"330";;;
28;"R4,R22,R27";"R_0603_1608Metric_Pad1.05x0.95mm_HandSolder";3;"10k";;;
29;"R7,R8,R9,R10,R11,R12,R13,R14,R15,R16";"R_0603_1608Metric_Pad1.05x0.95mm_HandSolder";10;"1";;;
30;"R17";"R_0603_1608Metric_Pad1.05x0.95mm_HandSolder";1;"680";;;
31;"R18";"R_0603_1608Metric_Pad1.05x0.95mm_HandSolder";1;"3k";;;
32;"R19";"R_0603_1608Metric_Pad1.05x0.95mm_HandSolder";1;"100";;;
33;"R20,R30";"R_0603_1608Metric_Pad1.05x0.95mm_HandSolder";2;"27k";;;
34;"R21,R23";"R_0603_1608Metric_Pad1.05x0.95mm_HandSolder";2;"220R";;;
35;"R24";"R_0603_1608Metric_Pad1.05x0.95mm_HandSolder";1;"100R";;;
36;"R25,R29";"R_0603_1608Metric_Pad1.05x0.95mm_HandSolder";2;"10kR";;;
37;"R26,R28";"R_0603_1608Metric_Pad1.05x0.95mm_HandSolder";2;"180k";;;
38;"R31";"R_0603_1608Metric_Pad1.05x0.95mm_HandSolder";1;"68k";;;
39;"R33";"R_0603_1608Metric_Pad1.05x0.95mm_HandSolder";1;"100k";;;
40;"SW1,SW2";"RotaryEncoder_Alps_EC12E_Vertical_H20mm";2;"Rotary_Encoder";;;
41;"SW3";"TerminalBlock_bornier-2_P5.08mm";1;"SW_Mains";;;
42;"T1";"Transformer_Toroid_Horizontal_D18.0mm";1;"Transformer_1P_1S";;;
43;"U1";"TQFP-32_7x7mm_P0.8mm";1;"ATmega328P-AU";;;
44;"U2,U3";"SOIC-8_3.9x4.9mm_P1.27mm";2;"LM358";;;
45;"U5";"TO-92_Inline";1;"LM334Z";;;
46;"U6";"SOT-89-3_Handsoldering";1;"L78L33_SOT89";;;
47;"U7";"TO-92_Inline";1;"LM336";;;
48;"U8";"SOT-23_Handsoldering";1;"REF3020";;;
49;"U9";"SOIC-8_3.9x4.9mm_P1.27mm";1;"MAX4080T";;;
50;"U10";"TO-252-2";1;"MC78M05_TO252";;;
51;"U11";"SOIC-8_3.9x4.9mm_P1.27mm";1;"INA219AxD";;;
52;"U12";"SOIC-14_3.9x8.7mm_P1.27mm";1;"MCP4922";;;
53;"Y1";"Crystal_HC52-8mm_Vertical";1;"20MHz Crystal";;;

## KiCad design 25v PSU.kicad_pcb

Parts:
C1, C2: 4700uF; C_Radial_D16.0mm_H25.0mm_P7.50mm
C3, C4, C5: 470u; C_Radial_D6.3mm_H7.0mm_P2.50mm
C6, C7, C12, C13: 100n; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C8, C9, C14: 0.1u; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C10: 1u; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C11: 2.2u; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C(Tantalum)1: 10u; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C?(Ceramic)1: 0.1u; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1, D2, D3, D4, D5, D6: D; D_SOD-123F
D7: D_Zener; D_MiniMELF_Handsoldering
D8: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1: Live; MountingHole_2.5mm_Pad
H2: Neutral; MountingHole_2.5mm_Pad_Via
H3: Out+; MountingHole_2.5mm_Pad
H4: Out-; MountingHole_2.5mm_Pad_Via
J1: Conn_01x10_Female; PinHeader_1x10_P2.54mm_Vertical
J2: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
K1: G5V-1; Relay_SPDT_Omron_G5V-1
Q1, Q2: TIP3055G; TO-247-3_Vertical
Q3, Q4: MMBT3904; SOT-23
R1, R4: 10kR; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R2, R3: 220R; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R5: 68k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R6: 100k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R7, R30: 27k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R8, R9, R10, R25: 330; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R11, R12, R13, R14, R15, R16, R17, R21, R22, R23: 1; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R18, R19: 180k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R20: 100R; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R24, R32: 10k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R26, R27: 4.7k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R28: 680; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R29: 100; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R31: 3k; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
SW1, SW2: Rotary_Encoder; RotaryEncoder_Alps_EC12E_Vertical_H20mm
SW3: SW_Mains; TerminalBlock_bornier-2_P5.08mm
T1: Transformer_1P_1S; Transformer_Toroid_Horizontal_D18.0mm
U1, U10: LM358; SOIC-8_3.9x4.9mm_P1.27mm
U2: LM336; TO-92_Inline
U3: MC78M05_TO252; TO-252-2
U4: MAX4080T; SOIC-8_3.9x4.9mm_P1.27mm
U5: LT3080xST; SOT-223
U6: MCP4922; SOIC-14_3.9x8.7mm_P1.27mm
U7: LM334Z; TO-92_Inline
U8: ATmega328P-AU; TQFP-32_7x7mm_P0.8mm
U9: L78L33_SOT89; SOT-89-3
U11: REF3020; SOT-23
U12: INA219AxD; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 8MHz Crystal; Crystal_HC52-6mm_Vertical

Connections:
2.048V: U6.11 (VrefB), U6.13 (VrefA), U8.20, U11.2 (OUT)
3.3V: C9.1, C13.1, C14.1, C(Tantalum)1.1, C?(Ceramic)1.1, J1.1, J2.2, R26.1, R27.1, R32.1, U6.1 (Vdd), U6.9 (~SHDN), U8.4, U8.6, U8.18, U9.1 (OUT), U11.1 (IN), U12.5 (VS)
5V: C7.1, C12.1, K1.2, R8.2, R9.2, R10.2, U3.3 (VO), U9.3 (IN)
Encoder1A: SW1.A, U8.10
Encoder1B: SW1.B, U8.9
Encoder2A: SW2.A, U8.2
Encoder2B: SW2.B, U8.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C(Tantalum)1.2, C?(Ceramic)1.2, D4.2 (A), D5.2 (A), D7.2 (A), H4.1, J1.2, J2.6, K1.1, K1.9, Q4.2 (E), R4.2, R7.2, R20.2, R24.2, R25.2, R31.1, SW1.C, SW2.C, U1.4 (V-), U2.3 (A), U3.2 (GND), U4.4 (GND), U6.8 (~LDAC), U6.12 (Vss), U7.3, U8.3, U8.5, U8.21, U9.2 (GND), U10.4 (V-), U11.3 (GND), U12.1 (A1), U12.2 (A0), U12.6 (GND)
Io: U4.5 (OUT), U10.5 (+)
IoRef: U6.10 (VB), U10.6 (-)
MISO: J1.4, J2.1, U8.16
MOSI: J1.7, J2.4, U6.5 (SDI), U8.15
unnamed: C3.1, R2.1, R3.2
unnamed: C4.1, Q2.1 (B), R3.1, R4.1
unnamed: C5.1, D1.2 (A), K1.10, Q1.3 (E), Q3.3 (C), U1.5 (+)
unnamed: C6.1, Q3.2 (E), U3.1 (VI)
unnamed: C8.1, C10.1, D6.1 (K), R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, R21.1, R22.1, R23.1, U5.3 (IN)
unnamed: C11.1, D6.2 (A), D7.1 (K), H3.1, R18.1, R19.1, U5.2 (OUT), U5.4 (OUT), U7.1
unnamed: D2.2 (A), D4.1 (K), T1.4 (SB)
unnamed: D3.2 (A), D5.1 (K), T1.3 (SA)
unnamed: D8.1 (K), R25.1
unnamed: D8.2 (A), U8.23
unnamed: H1.1, SW3.1 (A)
unnamed: H2.1, T1.2 (AB)
unnamed: J1.8, R8.1
unnamed: J1.9, R9.1
unnamed: J1.10, R10.1
unnamed: Q3.1 (B), U1.7
unnamed: Q4.1 (B), U10.7
unnamed: Q4.3 (C), R28.1, R29.2
unnamed: R1.2, U1.3 (+), U2.2 (K)
unnamed: R5.1, R6.2
unnamed: R5.2, R7.1, U1.2 (-)
unnamed: R6.1, U1.1, U1.6 (-)
unnamed: R20.1, U7.2
unnamed: R28.2, U10.1
unnamed: R30.2, R31.2, U10.2 (-)
unnamed: SW3.2 (B), T1.1 (AA)
RESET: J1.3, J2.5, R32.2, U8.29
SCK: J1.6, J2.3, U6.4 (SCK), U8.17
SCL0: R27.2, U8.28, U12.4 (SCL)
SDA0: R26.2, U8.27, U12.3 (SDA)
SS0: J1.5, U8.14
SS1: U6.3 (~CS), U8.13
Sense+: C8.2, K1.5, K1.6, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R21.2, R22.2, R23.2, U4.1 (RS+), U4.2 (Vcc), U10.8 (V+), U12.8 (IN+)
Sense-: U4.8 (RS-), U12.7 (IN-)
VSet: R29.1, R30.1, U5.1 (SET)
VoRef: U6.14 (VA), U10.3 (+)
Voutput: R18.2, R19.2, R24.1, U8.11
XTAL1: U8.7, Y1.1
XTAL2: U8.8, Y1.2
unreg: C1.1, C2.1, D1.1 (K), D2.1 (K), D3.1 (K), Q1.1 (B), Q1.2 (C), Q2.2 (C), Q2.3 (E), R1.1, R2.2, U1.8 (V+)

Notes on the sheet:
10x Gain for 0-20.48V
Mains to 18.22V out. Turn on at 18V. 1mV ripple.
DAC
Current ADC
Gain=20. 0-2V Out for 0-1A
Voltage Reference
Current Sense
Voltage output signal
Linear Output stage
3.3V regulator
AVR ISP Header
Clock Signal
ADDR=0
SPI1
SPI0
Rotary Encoders
SPI1 CS0
CS1
I2C0
LCD Display
Microprocessor
Linear power supply
10/04/2020

Board: 2 copper layers, 139.7 x 63.5 mm, 84 parts (0 on the bottom side), 52 nets.

## Code that names these connections

File atmegaCode/main.c:

#ifndef F_CPU					// if F_CPU was not defined in Project -> Properties
#define F_CPU 1000000UL			// define it now as 1 MHz unsigned long
#endif

//Define SPI Pins and functions
#define SPI_DDR DDRB
#define CS      PINB1
#define MOSI    PINB3
#define MISO    PINB4
#define SCK     PINB5
#define SPI_SLAVE_SELECTED PORTB &= ~(1 << CS)
#define SPI_SLAVE_DESELECTED PORTB |= (1 << CS)

#include <avr/io.h>				// this is always included in AVR programs
#include <util/delay.h>			// add this to use the delay function
#include <avr/pgmspace.h>
#include <avr/interrupt.h>

void SPI_init()
{
	SPI_DDR |= (1 << PINB2) | (1 << CS) | (1 << MOSI) | (1 << SCK);// set CS, MOSI and SCK to output
	SPCR = (1 << SPE) | (1 << MSTR) | (1 << SPR1) | (1 << SPR0);	// enable SPI, set as master, and clock to fosc/128
}

void TWIInit(void)
{
	//set SCL to 400kHz
	TWSR = 0x00;
	TWBR = 0x0C;
	//enable TWI
	TWCR = (1<<TWEN);
}

void TWIStart(void)
{
	TWCR = (1<<TWINT)|(1<<TWSTA)|(1<<TWEN);
	while ((TWCR & (1<<TWINT)) == 0);
}
//send stop signal
void TWIStop(void)
{
	TWCR = (1<<TWINT)|(1<<TWSTO)|(1<<TWEN);
}

void TWIWrite(uint8_t u8data)
{
	TWDR = u8data;
	TWCR = (1<<TWINT)|(1<<TWEN);
	while ((TWCR & (1<<TWINT)) == 0);
}

uint8_t TWIReadACK(void)
{
	TWCR = (1<<TWINT)|(1<<TWEN)|(1<<TWEA);
	while ((TWCR & (1<<TWINT)) == 0);
	return TWDR;
}
//read byte with NACK
uint8_t TWIReadNACK(void)
{
	TWCR = (1<<TWINT)|(1<<TWEN);
	while ((TWCR & (1<<TWINT)) == 0);
	return TWDR;
}

uint8_t TWIGetStatus(void)
{
	uint8_t status;
	//mask status
	status = TWSR & 0xF8;
	return status;
}

void SPI_MasterTransmit(uint8_t cData)
{
	SPDR = cData;//Start data send
	while(!(SPSR & (1<<SPIF)));//wait for completion flag
}

void outputVoltage(uint16_t outputVal){
	outputVal &= 0x0FFF;
	outputVal |= 0x3000;
	uint8_t msbTransfer = outputVal >> 8;
	uint8_t LSBTransfer = outputVal;
	SPI_SLAVE_SELECTED;
	SPI_MasterTransmit(msbTransfer);
	SPI_MasterTransmit(LSBTransfer);
	SPI_SLAVE_DESELECTED;
}

void outputCurrent(uint16_t outputVal){
	outputVal &= 0x0FFF;
	outputVal |= 0xB000;
	uint8_t msbTransfer = outputVal >> 8;
	uint8_t LSBTransfer = outputVal;
	SPI_SLAVE_SELECTED;
	SPI_MasterTransmit(msbTransfer);
	SPI_MasterTransmit(LSBTransfer);
	SPI_SLAVE_DESELECTED;
}

void initINA219(void){
	TWIStart();
		TWIWrite(0B10000000);
		TWIWrite(0B00000000);
		TWIWrite(0B00111001);
		TWIWrite(0B10011101);
	TWIStop();
	_delay_ms(10);
	TWIStart();
		TWIWrite(0B10000000);
		TWIWrite(0B00000001);
	TWIStop();
	//
}

uint16_t currentCurrent(void){
	uint16_t readCurrent =0;
	TWIStart();
	TWIWrite(0B10000001);
	readCurrent = (TWIReadACK()<<8);
	readCurrent |= TWIReadNACK();//current is readval/10 mA
	TWIStop();
	return readCurrent;
}

void turnLEDON(){
	PORTC |= (1 << PC0);	// LED ON
}

void invertLEDState(){
	PORTC ^= (1 << PC0);	// LED ON
}

void initRotary(){

	DDRD &=~ (1 << PD3);				/* PD2 and PD3 as input */
	DDRD &=~ (1 << PD4);
	PORTD |= (1 << PD3)|(1 << PD4);   /* PD2 and PD3 pull-up enabled   */

	GICR |= (1<<INT0)|(1<<INT1);		/* enable INT0 and INT1 */
	MCUCR |= (1<<ISC01)|(1<<ISC11)|(1<<ISC10); /* INT0 - falling edge, INT1 - reising edge */

}

uint16_t rotaryValue=0;

ISR(INT10_vect )
{
	if(!bit_is_clear(PIND, PD3))
	{
		rotaryValue++;
		invertLEDState();
	}
	else
	{
		rotaryValue--;
	}
}

//INT1 interrupt
ISR(INT1_vect )
{
	if(!bit_is_clear(PIND, PD4))
	{
		rotaryValue++;
		invertLEDState();
	}
	else
	{
		rotaryValue--;
	}
}

int main(void) {
	
	DDRC |= (1 << PC0);			// set Port C pin PC0 for output
	SPI_init();
	TWIInit();
	uint16_t outputValue=200*5;//4095 max
	uint16_t outputValue2=0x07FF;//4095 max
	uint16_t readCurrent =0;
	
	initRotary();
	sei();
	
	initINA219();
	_delay_ms(10);
	
	while (1) {
		outputVoltage(outputValue);
		outputCurrent(outputValue2);
		readCurrent = currentCurrent();
		if(readCurrent>500){
			//turnLEDON();
		}
		if(readCurrent<500){
			//invertLEDState();
		}
		_delay_ms(50);
	}
	return(0);					
}

//current LSB = 1/2^15=0.00003051757
//Config bytes 0011100110011101

/*

*/

## Commit log

2020-04-14 init
2020-04-14 Tidied files
2020-05-10 added first draft code
2020-05-10 untested rotary encoder test
2020-06-07 design updates
2020-06-08 V2 design complete

Notices in the files:
Kicad/OpenPSU.kicad_pcb:
Designed and made by Hamish Sams © 2020
